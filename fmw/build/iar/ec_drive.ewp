# IAR project ec_drive.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\app; ..\..\bsp\stm8\bldc; ..\..\bsp\stm8\stm8l15x_periph_lib\inc; ..\..\bsp\stm8\trace; ..\..\lib\function\bldc; ..\..\lib\abstract\ringbuffer
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../../app/: main.c stm8l15x_conf.h
  group bsp/bldc
    ../../bsp/stm8/bldc/: bldc_motor_hall.c bldc_motor_hall.h bldc_motor_load.c bldc_motor_load.h bldc_motor_pwm.c bldc_motor_pwm.h bldc_motor_speed.c bldc_motor_speed.h stm8_bldc_motor.c stm8_bldc_motor.h
  group bsp/periph
    ../../bsp/stm8/stm8l15x_periph_lib/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
    ../../bsp/stm8/stm8l15x_periph_lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group bsp/trace
    ../../bsp/stm8/trace/: stm8_tarce.c stm8_trace.h
  group lib/abstract/ringbuffer
    ../../lib/abstract/ringbuffer/: ringbuffer.c ringbuffer.h
  group lib/function/bldc
    ../../lib/function/bldc/: bldc_motor.c bldc_motor.h
